## conf/distro/include/petalinux-mirrors.conf
```bitbake
INHERIT += "own-mirrors"
SOURCE_MIRROR_URL ?= "http://petalinux.xilinx.com/sswreleases/rel-v2023/downloads"
```
